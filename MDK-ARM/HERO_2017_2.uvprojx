# Keil uVision project HERO_2017_2.uvprojx, settings and files
target HERO_2017_2 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HERO_2017_2 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;..\eMPL;..\HARDWARE\IIC;..\HARDWARE\OLED;..\Judgement\JUDGEMENT;..\Judgement\DATAFIFO;..\Judgement\Heat;..\Judgement\PROTICOL;..\Judgement\UI;..\Judgement\RM_Cilent_UI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_flash.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group BKD
    ../Src/: test_imu.c bkd_remote.c bkd_can.c bkd_pid.c bkd_feedmotor.c bkd_Small_gyroscope.c bkd_control.c bkd_Autoaiming.c bkd_usart.c
    ../: 修改日志.txt
  group Application/User
    ../Src/: main.c usart.c stm32f4xx_hal_msp.c can.c stm32f4xx_it.c spi.c tim.c dma.c iwdg.c gpio.c delay.c adc.c sys.c
  group Judgement
    ../Judgement/DATAFIFO/: data_fifo.c
    ../Judgement/Heat/: Heat.c
    ../Judgement/JUDGEMENT/: judgement.c
    ../Judgement/PROTICOL/: proticol.c
    ../Judgement/RM_Cilent_UI/: RM_Cilent_UI.c
    ../Judgement/UI/: ui.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.3.1
